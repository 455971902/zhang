# IAR project asad0.2.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F5438 MSP430F5438
  General.GStackSize2: 1024
  General.GHeapSize2: 4096
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: kernel; port; driver\adc12; driver\charge; driver\bmp085; driver\flash; driver\key; driver\lcd; driver\msp430x54x; driver\pump; driver\rtc; driver\ds18b20; driver\fm24c64; gui; eeprom
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438A.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 512
  ICC430.newCCIncludePaths: driver\bmp085; driver\ds18b20; kernel; port; driver\adc12; driver\charge; driver\flash; driver\key; driver\lcd; driver\msp430x54x; driver\pump; driver\rtc; gui
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  group (top)
    ./: bsp.c main.c
  group driver/adc12
    driver/adc12/: adc12.c
  group driver/bmp085
    driver/bmp085/: bmp085.c
  group driver/charge
    driver/charge/: charger.c
  group driver/ds18b20
    driver/ds18b20/: ds18b20.c
  group driver/flash
    driver/flash/: flash.c
  group driver/fm24c64
    driver/fm24c64/: iic.c iic.h
  group driver/key
    driver/key/: key.c
  group driver/lcd
    driver/lcd/: lcd.c
  group driver/msp430x54x
    driver/msp430x54x/: chip.c
  group driver/pump
    driver/pump/: pump.c
  group driver/rtc
    driver/rtc/: ds1302.c
  group eeprom
    eeprom/: eeprom.c parameter.h
  group gui
    gui/: display.c menu.c system.c test.c windows.c
  group kernel
    kernel/: isr.c os.c schdule.c semaphore.c stack.c task.c tick.c timer.c
  group port
    port/: port_a.s43 port_c.c
