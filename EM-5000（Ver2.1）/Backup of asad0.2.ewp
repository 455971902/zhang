# IAR project Backup of asad0.2.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F5438 MSP430F5438
  General.GStackSize2: 512
  General.GHeapSize2: 4096
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: kernel; port\msp430x5438x; driver\adc12; driver\charge; driver\flash; driver\key; driver\lcd; driver\msp430x54x; driver\pump; driver\rtc; gui
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: bsp.c main.c
  group driver/adc12
    driver/adc12/: adc12.c
  group driver/charge
    driver/charge/: charger.c
  group driver/flash
    driver/flash/: flash.c
  group driver/key
    driver/key/: key.c
  group driver/lcd
    driver/lcd/: lcd.c
  group driver/msp430x54x
    driver/msp430x54x/: chip.c
  group driver/pump
    driver/pump/: pump.c
  group driver/rtc
    driver/rtc/: ds1302.c
  group gui
    gui/: display.c menu.c system.c test.c windows.c
  group kernel
    kernel/: isr.c os.c schdule.c semaphore.c stack.c task.c tick.c timer.c
  group port
    port/msp430x5438x/: port_a.s43 port_c.c
